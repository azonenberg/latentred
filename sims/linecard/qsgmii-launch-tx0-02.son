qsgmii-launch-tx0-02.son:
```
FTYP SONPROJ 19 ! Sonnet Project File
VER 18.56
HEADER
LIC antikernel2.1.65565
DAT 12/22/2024 09:46:08
BUILT_BY_CREATED xgeom 18.52 11/18/2021 20:28:07
BUILT_BY_SAVED sonnet 18.56
MDATE 12/22/2024 09:46:08
HDATE 12/22/2024 09:46:08
ANN Created by dxfgeo, Sonnet Software Inc.
END HEADER
DIM
ANG DEG
CAP PF
CON /OH
FREQ GHZ
IND NH
LNG MM
RES OH
END DIM
CONTROL
VARSWP
OPTIONS  -dj
SPEED 1
CACHE_ABS 2
Q_ACC N
END CONTROL
GEO
TMET "Free Space" 0 FREESPACE 376.7303136 0 0 0
BMET "Free Space" 0 FREESPACE 376.7303136 0 0 0
MET "Copper_1oz_thin" 1 NOR 58000000 0.5 0.035 
MET "Copper_1oz_thick" 2 TMM 58000000 0.5 0.035 2
MET "Copper_1oz_thick_down" 3 TMM 58000000 0.5 0.035 2 CDVY TDWN
MET "Copper_0.5oz_thin" 4 NOR 58000000 0.5 0.017 
MET "Copper_0.5oz_thick" 12 TMM 58000000 0.5 0.017 2
MET "Copper_0.5oz_thick_down" 5 TMM 58000000 0.5 0.017 2 CDVY TDWN
BOX 8 20 5 2000 500 20 0
      5 1 1 0 0 0 0 "Air"
      0.04 3.5 1 0.025 0 0 0 "Soldermask"
      0.076 4.49 1 0.016 0 0 0 "Shengyi_S1000-2M"
      0.1 4.49 1 0.016 0 0 0 "Shengyi_S1000-2M"
      1.038 4.49 1 0.016 0 0 0 "Shengyi_S1000-2M"
      0.1 4.49 1 0.016 0 0 0 "Shengyi_S1000-2M"
      0.076 4.49 1 0.016 0 0 0 "Shengyi_S1000-2M"
      0.04 3.5 1 0.025 0 0 0 "Soldermask"
      5 1 1 0 0 0 0 "Air"
TECHLAY METAL F.Cu_thick L1D0 -2 -65534 CAD F.Cu_thick drawing 
1 0 1 N 1157 1 1 100 100 0 0 0 Y
END
END
TECHLAY VIA Via1 L7D0 -13 -65534 CAD Via1 drawing 
VIA POLYGON
1 0 -1 N 1385 1 1 100 100 0 0 0 Y
TOLEVEL 6 RING NOCOVERS
END
END
TECHLAY METAL F.Cu_thin <UNSPECIFIED> -1 -65534 CAD F.Cu_thin drawing 
1 0 0 N 1161 1 1 100 100 0 0 0 Y
END
END
TECHLAY METAL In1.Cu L2D0 -3 -65534 CAD In1.Cu drawing 
2 0 0 N 1164 1 1 100 100 0 0 0 Y
END
END
TECHLAY METAL In2.Cu_thin L3D0 -4 -65534 CAD In2.Cu drawing 
3 0 3 N 1167 1 1 100 100 0 0 0 Y
END
END
TECHLAY METAL In2.Cu_thick <UNSPECIFIED> -5 -65534 CAD In2.Cu_thick drawing 
3 0 4 N 1169 1 1 100 100 0 0 0 Y
END
END
TECHLAY METAL In3.Cu_thin L4D0 -8 -65534 CAD In5.Cu drawing 
4 0 3 N 1172 1 1 100 100 0 0 0 Y
END
END
TECHLAY METAL In4.Cu L5D0 -10 -65534 CAD In6.Cu drawing 
5 0 0 N 1175 1 1 100 100 0 0 0 Y
END
END
TECHLAY METAL B.Cu_thick L6D0 -12 -65534 CAD B.Cu_thick drawing 
6 0 2 N 1178 1 1 100 100 0 0 0 Y
END
END
TECHLAY METAL B.Cu_thin <UNSPECIFIED> -11 -65534 CAD B.Cu_thin drawing 
6 0 0 N 1180 1 1 100 100 0 0 0 Y
END
END
TECHLAY METAL In3.Cu_thick <UNSPECIFIED> -9 -65534 CAD In5.Cu_thick drawing 
8 0 5 N 1184 1 1 100 100 0 0 0 Y
END
END
LORGN 0 5 U 
POR1 CUP Auto
GNDREF AUTO
TERMW FEED
POLY 42 1
87
-2 100 0 0 0 16.95 2.0305 
CUPGRP "Auto" LOCAL
ID 1381
END
POR1 CUP Auto
GNDREF AUTO
TERMW FEED
POLY 43 1
84
2 100 0 0 0 16.95 2.6655 
CUPGRP "Auto" LOCAL
ID 1382
END
POR1 CUP Auto
GNDREF AUTO
TERMW FEED
POLY 1312 1
56
1 100 0 0 0 0.65 3.5 
CUPGRP "Auto" LOCAL
ID 1383
END
POR1 CUP Auto
GNDREF AUTO
TERMW FEED
POLY 1313 1
418
-1 100 0 0 0 1.65 3.5 
CUPGRP "Auto" LOCAL
ID 1384
END
SMD 1 "C1"
ID 1390
GNDREF FLOAT
SBOX 5.525 5.775 2.918 2.993
PBSHW N
LPOS 5.65 2.918
TYPE IDEAL CAP 100000
SMDP 1 5.4 2.9555 L 3 1 
EXSMDP
GNDREF AUTO
TERMW FEED
END EXSMDP
SMDP 1 5.9 2.9555 R 4 2 
EXSMDP
GNDREF AUTO
TERMW FEED
END EXSMDP
END
SMD 1 "C2"
ID 1395
GNDREF FLOAT
SBOX 5.525 5.775 3.918 3.993
PBSHW N
LPOS 5.65 3.918
TYPE IDEAL CAP 100000
SMDP 1 5.4 3.9555 L 5 1 
EXSMDP
GNDREF AUTO
TERMW FEED
END EXSMDP
SMDP 1 5.9 3.9555 R 6 2 
EXSMDP
GNDREF AUTO
TERMW FEED
END EXSMDP
END
NUM 44
1 89 1 N 35 1 1 100 100 0 0 0 Y
TLAYNAM F.Cu_thick INH
16.95 1.3035
16.951 1.2955
16.953 1.2865
16.955 1.2785
16.958 1.2705
16.962 1.2635
16.967 1.2555
16.985 1.2375
16.993 1.2325
17 1.2285
17.008 1.2255
17.016 1.2235
17.025 1.2215
17.033 1.2205
17.309 1.2205
17.316 1.2145
17.334 1.2025
17.354 1.1925
17.374 1.1835
17.395 1.1775
17.417 1.1725
17.439 1.1705
17.461 1.1705
17.483 1.1725
17.505 1.1775
17.526 1.1835
17.546 1.1925
17.566 1.2025
17.584 1.2145
17.591 1.2205
17.867 1.2205
17.875 1.2215
17.884 1.2235
17.892 1.2255
17.9 1.2285
17.907 1.2325
17.915 1.2375
17.933 1.2555
17.938 1.2635
17.942 1.2705
17.945 1.2785
17.947 1.2865
17.949 1.2955
17.95 1.3035
17.95 1.4875
17.949 1.4955
17.947 1.5045
17.945 1.5125
17.942 1.5205
17.938 1.5275
17.933 1.5355
17.915 1.5535
17.907 1.5585
17.9 1.5625
17.892 1.5655
17.884 1.5675
17.875 1.5695
17.867 1.5705
17.591 1.5705
17.584 1.5765
17.566 1.5885
17.546 1.5985
17.526 1.6075
17.505 1.6135
17.483 1.6185
17.461 1.6205
17.439 1.6205
17.417 1.6185
17.395 1.6135
17.374 1.6075
17.354 1.5985
17.334 1.5885
17.316 1.5765
17.309 1.5705
17.033 1.5705
17.025 1.5695
17.016 1.5675
17.008 1.5655
17 1.5625
16.993 1.5585
16.985 1.5535
16.967 1.5355
16.962 1.5275
16.958 1.5205
16.955 1.5125
16.953 1.5045
16.951 1.4955
16.95 1.4875
16.95 1.3035
END
1 89 1 N 36 1 1 100 100 0 0 0 Y
TLAYNAM F.Cu_thick INH
16.95 3.2085
16.951 3.2005
16.953 3.1915
16.955 3.1835
16.958 3.1755
16.962 3.1685
16.967 3.1605
16.985 3.1425
16.993 3.1375
17 3.1335
17.008 3.1305
17.016 3.1285
17.025 3.1265
17.033 3.1255
17.309 3.1255
17.316 3.1195
17.334 3.1075
17.354 3.0975
17.374 3.0885
17.395 3.0825
17.417 3.0775
17.439 3.0755
17.461 3.0755
17.483 3.0775
17.505 3.0825
17.526 3.0885
17.546 3.0975
17.566 3.1075
17.584 3.1195
17.591 3.1255
17.867 3.1255
17.875 3.1265
17.884 3.1285
17.892 3.1305
17.9 3.1335
17.907 3.1375
17.915 3.1425
17.933 3.1605
17.938 3.1685
17.942 3.1755
17.945 3.1835
17.947 3.1915
17.949 3.2005
17.95 3.2085
17.95 3.3925
17.949 3.4005
17.947 3.4095
17.945 3.4175
17.942 3.4255
17.938 3.4325
17.933 3.4405
17.915 3.4585
17.907 3.4635
17.9 3.4675
17.892 3.4705
17.884 3.4725
17.875 3.4745
17.867 3.4755
17.591 3.4755
17.584 3.4815
17.566 3.4935
17.546 3.5035
17.526 3.5125
17.505 3.5185
17.483 3.5235
17.461 3.5255
17.439 3.5255
17.417 3.5235
17.395 3.5185
17.374 3.5125
17.354 3.5035
17.334 3.4935
17.316 3.4815
17.309 3.4755
17.033 3.4755
17.025 3.4745
17.016 3.4725
17.008 3.4705
17 3.4675
16.993 3.4635
16.985 3.4585
16.967 3.4405
16.962 3.4325
16.958 3.4255
16.955 3.4175
16.953 3.4095
16.951 3.4005
16.95 3.3925
16.95 3.2085
END
1 89 1 N 42 1 1 100 100 0 0 0 Y
TLAYNAM F.Cu_thick INH
16.95 1.9385
16.951 1.9305
16.953 1.9215
16.955 1.9135
16.958 1.9055
16.962 1.8985
16.967 1.8905
16.985 1.8725
16.993 1.8675
17 1.8635
17.008 1.8605
17.016 1.8585
17.025 1.8565
17.033 1.8555
17.867 1.8555
17.875 1.8565
17.884 1.8585
17.892 1.8605
17.9 1.8635
17.907 1.8675
17.915 1.8725
17.933 1.8905
17.938 1.8985
17.942 1.9055
17.943 1.9085
17.954 1.9025
17.974 1.8935
17.995 1.8875
18.017 1.8825
18.039 1.8805
18.061 1.8805
18.083 1.8825
18.105 1.8875
18.126 1.8935
18.146 1.9025
18.166 1.9125
18.184 1.9245
18.201 1.9385
18.217 1.9545
18.231 1.9715
18.243 1.9895
18.253 2.0095
18.262 2.0295
18.268 2.0505
18.273 2.0725
18.275 2.0945
18.275 2.1165
18.273 2.1385
18.268 2.1605
18.262 2.1815
18.253 2.2015
18.243 2.2215
18.231 2.2395
18.217 2.2565
18.201 2.2725
18.184 2.2865
18.166 2.2985
18.146 2.3085
18.126 2.3175
18.105 2.3235
18.083 2.3285
18.061 2.3305
18.039 2.3305
18.017 2.3285
17.995 2.3235
17.974 2.3175
17.954 2.3085
17.934 2.2985
17.916 2.2865
17.899 2.2725
17.883 2.2565
17.869 2.2395
17.857 2.2215
17.849 2.2055
17.033 2.2055
17.025 2.2045
17.016 2.2025
17.008 2.2005
17 2.1975
16.993 2.1935
16.985 2.1885
16.967 2.1705
16.962 2.1625
16.958 2.1555
16.955 2.1475
16.953 2.1395
16.951 2.1305
16.95 2.1225
16.95 1.9385
END
1 86 1 N 43 1 1 100 100 0 0 0 Y
TLAYNAM F.Cu_thick INH
16.95 2.5735
16.951 2.5655
16.953 2.5565
16.955 2.5485
16.958 2.5405
16.962 2.5335
16.967 2.5255
16.985 2.5075
16.993 2.5025
17 2.4985
17.008 2.4955
17.016 2.4935
17.025 2.4915
17.033 2.4905
17.867 2.4905
17.875 2.4915
17.884 2.4935
17.892 2.4955
17.899 2.4885
17.916 2.4745
17.934 2.4625
17.954 2.4525
17.974 2.4435
17.995 2.4375
18.017 2.4325
18.039 2.4305
18.061 2.4305
18.083 2.4325
18.105 2.4375
18.126 2.4435
18.146 2.4525
18.166 2.4625
18.184 2.4745
18.201 2.4885
18.217 2.5045
18.231 2.5215
18.243 2.5395
18.253 2.5595
18.262 2.5795
18.268 2.6005
18.273 2.6225
18.275 2.6445
18.275 2.6665
18.273 2.6885
18.268 2.7105
18.262 2.7315
18.253 2.7515
18.243 2.7715
18.231 2.7895
18.217 2.8065
18.201 2.8225
18.184 2.8365
18.166 2.8485
18.146 2.8585
18.126 2.8675
18.105 2.8735
18.083 2.8785
18.061 2.8805
18.039 2.8805
18.017 2.8785
17.995 2.8735
17.974 2.8675
17.954 2.8585
17.934 2.8485
17.916 2.8365
17.907 2.8285
17.9 2.8325
17.892 2.8355
17.884 2.8375
17.875 2.8395
17.867 2.8405
17.033 2.8405
17.025 2.8395
17.016 2.8375
17.008 2.8355
17 2.8325
16.993 2.8285
16.985 2.8235
16.967 2.8055
16.962 2.7975
16.958 2.7905
16.955 2.7825
16.953 2.7745
16.951 2.7655
16.95 2.7575
16.95 2.5735
END
1 65 1 N 60 1 1 100 100 0 0 0 Y
TLAYNAM F.Cu_thick INH
5.925 2.1945
5.927 2.1725
5.932 2.1505
5.938 2.1295
5.947 2.1095
5.957 2.0895
5.969 2.0715
5.983 2.0545
5.999 2.0385
6.016 2.0245
6.034 2.0125
6.054 2.0025
6.074 1.9935
6.095 1.9875
6.117 1.9825
6.139 1.9805
6.161 1.9805
6.183 1.9825
6.205 1.9875
6.226 1.9935
6.246 2.0025
6.266 2.0125
6.284 2.0245
6.301 2.0385
6.317 2.0545
6.331 2.0715
6.343 2.0895
6.353 2.1095
6.362 2.1295
6.368 2.1505
6.373 2.1725
6.375 2.1945
6.375 2.2165
6.373 2.2385
6.368 2.2605
6.362 2.2815
6.353 2.3015
6.343 2.3215
6.331 2.3395
6.317 2.3565
6.301 2.3725
6.284 2.3865
6.266 2.3985
6.246 2.4085
6.226 2.4175
6.205 2.4235
6.183 2.4285
6.161 2.4305
6.139 2.4305
6.117 2.4285
6.095 2.4235
6.074 2.4175
6.054 2.4085
6.034 2.3985
6.016 2.3865
5.999 2.3725
5.983 2.3565
5.969 2.3395
5.957 2.3215
5.947 2.3015
5.938 2.2815
5.932 2.2605
5.927 2.2385
5.925 2.2165
5.925 2.1945
END
1 5 1 N 75 1 1 100 100 0 0 0 Y
TLAYNAM F.Cu_thick INH
5.9 2.7055
6.4 2.7055
6.4 3.2055
5.9 3.2055
5.9 2.7055
END
1 5 1 N 76 1 1 100 100 0 0 0 Y
TLAYNAM F.Cu_thick INH
5.9 3.7055
6.4 3.7055
6.4 4.2055
5.9 4.2055
5.9 3.7055
END
1 59 1 N 1199 1 1 100 100 0 0 0 Y
TLAYNAM F.Cu_thick INH
5.927 4.7385
5.932 4.7605
5.938 4.7815
5.947 4.8015
5.957 4.8215
5.969 4.8395
5.983 4.8565
5.999 4.8725
6.016 4.8865
6.034 4.8985
6.054 4.9085
6.056222 4.9095
6.243778 4.9095
6.246 4.9085
6.266 4.8985
6.284 4.8865
6.301 4.8725
6.317 4.8565
6.331 4.8395
6.343 4.8215
6.353 4.8015
6.362 4.7815
6.368 4.7605
6.373 4.7385
6.375 4.7165
6.375 4.6945
6.373 4.6725
6.368 4.6505
6.362 4.6295
6.353 4.6095
6.343 4.5895
6.331 4.5715
6.317 4.5545
6.301 4.5385
6.284 4.5245
6.266 4.5125
6.246 4.5025
6.226 4.4935
6.205 4.4875
6.183 4.4825
6.161 4.4805
6.139 4.4805
6.117 4.4825
6.095 4.4875
6.074 4.4935
6.054 4.5025
6.034 4.5125
6.016 4.5245
5.999 4.5385
5.983 4.5545
5.969 4.5715
5.957 4.5895
5.947 4.6095
5.938 4.6295
5.932 4.6505
5.927 4.6725
5.925 4.6945
5.925 4.7165
5.927 4.7385
END
1 101 1 N 1312 1 1 100 100 0 0 0 Y
TLAYNAM F.Cu_thick INH
2.102 4.2495
2.107 4.2475
2.111 4.2465
2.115 4.2445
2.118 4.2415
2.122 4.2385
2.128 4.2325
2.129 4.2305
2.759 3.6005
4.357 3.6005
4.748 3.9915
4.752 3.9945
4.756 3.9965
4.76 3.9975
4.764 3.9995
4.768 4.0005
4.9 4.0005
4.9 4.2055
5.4 4.2055
5.4 3.7055
4.9 3.7055
4.9 3.9105
4.793 3.9105
4.402 3.5195
4.398 3.5165
4.394 3.5145
4.39 3.5135
4.386 3.5115
4.382 3.5105
2.734 3.5105
2.73 3.5115
2.726 3.5135
2.722 3.5145
2.718 3.5165
2.714 3.5195
2.073 4.1605
1.168 4.1605
0.837 3.8295
0.843 3.8215
0.853 3.8015
0.862 3.7815
0.868 3.7605
0.873 3.7385
0.875 3.7165
0.875 3.6945
0.873 3.6725
0.868 3.6505
0.862 3.6295
0.853 3.6095
0.843 3.5895
0.831 3.5715
0.817 3.5545
0.801 3.5385
0.784 3.5245
0.766 3.5125
0.746 3.5025
0.7404444444 3.5
0.5595555556 3.5
0.554 3.5025
0.534 3.5125
0.516 3.5245
0.499 3.5385
0.483 3.5545
0.469 3.5715
0.457 3.5895
0.447 3.6095
0.438 3.6295
0.432 3.6505
0.427 3.6725
0.425 3.6945
0.425 3.7165
0.427 3.7385
0.432 3.7605
0.438 3.7815
0.447 3.8015
0.457 3.8215
0.469 3.8395
0.483 3.8565
0.499 3.8725
0.516 3.8865
0.534 3.8985
0.554 3.9085
0.574 3.9175
0.595 3.9235
0.617 3.9285
0.639 3.9305
0.661 3.9305
0.683 3.9285
0.705 3.9235
0.726 3.9175
0.746 3.9085
0.766 3.8985
0.774 3.8925
1.123 4.2415
1.127 4.2445
1.131 4.2465
1.135 4.2475
1.139 4.2495
1.143 4.2505
2.098 4.2505
2.102 4.2495
END
1 450 1 N 1313 1 1 100 100 0 0 0 Y
TLAYNAM F.Cu_thick INH
1.683 3.9285
1.705 3.9235
1.726 3.9175
1.746 3.9085
1.766 3.8985
1.784 3.8865
1.801 3.8725
1.817 3.8565
1.831 3.8395
1.843 3.8215
1.853 3.8015
1.862 3.7815
1.868 3.7605
1.87 3.7505
2.316 3.7505
2.32 3.7495
2.324 3.7475
2.328 3.7465
2.332 3.7445
2.336 3.7415
2.677 3.4005
2.904 3.4005
2.906 3.3995
2.908 3.3995
2.931 3.3975
2.932 3.3975
2.936 3.3965
2.94 3.3945
2.944 3.3935
2.957 3.3895
2.962 3.3885
2.966 3.3865
2.97 3.3855
2.974 3.3835
2.975 3.3825
2.978 3.3805
3.002 3.3685
3.018 3.3545
3.02 3.3535
3.023 3.3505
3.027 3.3485
3.03 3.3445
3.05 3.3205
3.053 3.3165
3.068 3.2885
3.069 3.2845
3.071 3.2805
3.072 3.2765
3.072 3.2745
3.079 3.2535
3.08 3.2495
3.08 3.2355
3.081 3.2265
3.081 3.2255
3.082 3.2225
3.082 3.0485
3.083 3.0315
3.083 3.0305
3.089 3.0095
3.095 2.9955
3.104 2.9815
3.115 2.9705
3.135 2.9575
3.144 2.9535
3.161 2.9495
3.183 2.9475
3.241 2.9475
3.267 2.9495
3.283 2.9555
3.302 2.9655
3.315 2.9765
3.326 2.9885
3.334 3.0045
3.339 3.0175
3.339 3.0185
3.342 3.0495
3.342 3.2225
3.343 3.2245
3.343 3.2265
3.344 3.2455
3.345 3.2495
3.346 3.2545
3.348 3.2595
3.351 3.2695
3.351 3.2715
3.352 3.2765
3.354 3.2805
3.366 3.3065
3.368 3.3105
3.37 3.3125
3.384 3.3335
3.391 3.3405
3.394 3.3425
3.401 3.3495
3.403 3.3525
3.409 3.3585
3.424 3.3685
3.428 3.3725
3.432 3.3745
3.436 3.3775
3.462 3.3895
3.47 3.3915
3.475 3.3925
3.484 3.3945
3.488 3.3955
3.492 3.3975
3.497 3.3985
3.498 3.3985
3.516 3.3995
3.518 3.3995
3.52 3.4005
3.604 3.4005
3.606 3.3995
3.608 3.3995
3.631 3.3975
3.632 3.3975
3.636 3.3965
3.64 3.3945
3.644 3.3935
3.657 3.3895
3.662 3.3885
3.666 3.3865
3.67 3.3855
3.674 3.3835
3.675 3.3825
3.678 3.3805
3.702 3.3685
3.718 3.3545
3.72 3.3535
3.723 3.3505
3.727 3.3485
3.73 3.3445
3.75 3.3205
3.753 3.3165
3.768 3.2885
3.769 3.2845
3.771 3.2805
3.772 3.2765
3.772 3.2745
3.779 3.2535
3.78 3.2495
3.78 3.2355
3.781 3.2265
3.781 3.2255
3.782 3.2225
3.782 3.0495
3.785 3.0215
3.79 3.0065
3.8 2.9875
3.805 2.9805
3.806 2.9805
3.824 2.9645
3.842 2.9555
3.858 2.9495
3.884 2.9475
3.941 2.9475
3.967 2.9495
3.983 2.9555
4.002 2.9655
4.015 2.9765
4.026 2.9885
4.034 3.0045
4.039 3.0175
4.039 3.0185
4.042 3.0495
4.042 3.2225
4.043 3.2245
4.043 3.2265
4.044 3.2455
4.045 3.2495
4.046 3.2545
4.048 3.2595
4.051 3.2695
4.051 3.2715
4.052 3.2765
4.054 3.2805
4.066 3.3065
4.068 3.3105
4.07 3.3125
4.084 3.3335
4.091 3.3405
4.094 3.3425
4.101 3.3495
4.103 3.3525
4.109 3.3585
4.124 3.3685
4.128 3.3725
4.132 3.3745
4.136 3.3775
4.162 3.3895
4.17 3.3915
4.175 3.3925
4.184 3.3945
4.188 3.3955
4.192 3.3975
4.197 3.3985
4.198 3.3985
4.216 3.3995
4.219 3.4005
4.382 3.4005
4.386 3.3995
4.39 3.3975
4.394 3.3965
4.398 3.3945
4.402 3.3915
4.793 3.0005
4.9 3.0005
4.9 3.2055
5.4 3.2055
5.4 2.7055
4.9 2.7055
4.9 2.9105
4.768 2.9105
4.764 2.9115
4.76 2.9135
4.756 2.9145
4.752 2.9165
4.748 2.9195
4.357 3.3105
4.233 3.3105
4.211 3.3085
4.194 3.3045
4.185 3.3005
4.165 3.2875
4.154 3.2765
4.145 3.2615
4.139 3.2485
4.133 3.2275
4.133 3.2265
4.132 3.2095
4.132 3.0355
4.131 3.0325
4.131 3.0315
4.13 3.0225
4.13 3.0085
4.129 3.0045
4.122 2.9835
4.122 2.9815
4.121 2.9775
4.119 2.9735
4.118 2.9695
4.103 2.9415
4.1 2.9375
4.08 2.9135
4.077 2.9095
4.073 2.9075
4.07 2.9045
4.068 2.9035
4.052 2.8895
4.028 2.8775
4.025 2.8745
4.024 2.8745
4.02 2.8725
4.016 2.8715
4.012 2.8695
4.007 2.8685
3.994 2.8645
3.986 2.8615
3.982 2.8605
3.981 2.8605
3.958 2.8585
3.956 2.8585
3.954 2.8575
3.87 2.8575
3.867 2.8585
3.866 2.8585
3.843 2.8605
3.835 2.8625
3.83 2.8645
3.818 2.8685
3.817 2.8685
3.813 2.8695
3.809 2.8715
3.804 2.8725
3.801 2.8745
3.8 2.8745
3.781 2.8855
3.777 2.8875
3.773 2.8905
3.77 2.8935
3.766 2.8965
3.759 2.9025
3.758 2.9025
3.755 2.9045
3.751 2.9075
3.745 2.9135
3.724 2.9375
3.712 2.9615
3.709 2.9645
3.709 2.9655
3.707 2.9695
3.706 2.9735
3.704 2.9775
3.703 2.9825
3.696 3.0035
3.695 3.0085
3.693 3.0315
3.693 3.0325
3.692 3.0355
3.692 3.2085
3.689 3.2395
3.689 3.2405
3.684 3.2535
3.676 3.2695
3.665 3.2815
3.652 3.2925
3.633 3.3025
3.617 3.3085
3.591 3.3105
3.533 3.3105
3.511 3.3085
3.494 3.3045
3.485 3.3005
3.465 3.2875
3.454 3.2765
3.445 3.2615
3.439 3.2485
3.433 3.2275
3.433 3.2265
3.432 3.2095
3.432 3.0355
3.431 3.0325
3.431 3.0315
3.43 3.0225
3.43 3.0085
3.429 3.0045
3.422 2.9835
3.422 2.9815
3.421 2.9775
3.419 2.9735
3.418 2.9695
3.403 2.9415
3.4 2.9375
3.38 2.9135
3.377 2.9095
3.373 2.9075
3.37 2.9045
3.368 2.9035
3.352 2.8895
3.328 2.8775
3.325 2.8745
3.324 2.8745
3.32 2.8725
3.316 2.8715
3.312 2.8695
3.307 2.8685
3.294 2.8645
3.286 2.8615
3.282 2.8605
3.281 2.8605
3.258 2.8585
3.256 2.8585
3.254 2.8575
3.168 2.8575
3.166 2.8585
3.148 2.8595
3.147 2.8595
3.142 2.8605
3.141 2.8615
3.125 2.8655
3.12 2.8665
3.112 2.8685
3.086 2.8805
3.082 2.8835
3.078 2.8855
3.074 2.8895
3.059 2.8995
3.053 2.9055
3.051 2.9085
3.044 2.9155
3.041 2.9175
3.034 2.9245
3.02 2.9455
3.018 2.9475
3.016 2.9515
3.004 2.9775
3.003 2.9795
3.003 2.9815
3.002 2.9835
3.001 2.9865
3.001 2.9885
2.998 2.9985
2.996 3.0035
2.995 3.0085
2.994 3.0125
2.993 3.0315
2.993 3.0335
2.992 3.0355
2.992 3.2085
2.989 3.2395
2.989 3.2405
2.984 3.2535
2.976 3.2695
2.965 3.2815
2.952 3.2925
2.933 3.3025
2.917 3.3085
2.891 3.3105
2.652 3.3105
2.647 3.3115
2.643 3.3135
2.639 3.3145
2.635 3.3165
2.631 3.3195
2.622 3.3285
2.621 3.3305
2.291 3.6605
1.87 3.6605
1.868 3.6505
1.862 3.6295
1.853 3.6095
1.843 3.5895
1.831 3.5715
1.817 3.5545
1.801 3.5385
1.784 3.5245
1.766 3.5125
1.746 3.5025
1.740444444 3.5
1.559555556 3.5
1.554 3.5025
1.534 3.5125
1.516 3.5245
1.499 3.5385
1.483 3.5545
1.469 3.5715
1.457 3.5895
1.447 3.6095
1.438 3.6295
1.432 3.6505
1.427 3.6725
1.425 3.6945
1.425 3.7165
1.427 3.7385
1.432 3.7605
1.438 3.7815
1.447 3.8015
1.457 3.8215
1.469 3.8395
1.483 3.8565
1.499 3.8725
1.516 3.8865
1.534 3.8985
1.554 3.9085
1.574 3.9175
1.595 3.9235
1.617 3.9285
1.639 3.9305
1.661 3.9305
1.683 3.9285
END
VIA POLYGON
1 5 -1 N 953 1 1 100 100 0 0 0 Y
TOLEVEL 6 RING NOCOVERS
TLAYNAM Via1 INH
17.325 1.2705
17.575 1.2705
17.575 1.5205
17.325 1.5205
17.325 1.2705
END
VIA POLYGON
1 5 -1 N 954 1 1 100 100 0 0 0 Y
TOLEVEL 6 RING NOCOVERS
TLAYNAM Via1 INH
17.325 3.1755
17.575 3.1755
17.575 3.4255
17.325 3.4255
17.325 3.1755
END
VIA POLYGON
1 5 -1 N 962 1 1 100 100 0 0 0 Y
TOLEVEL 6 RING NOCOVERS
TLAYNAM Via1 INH
17.925 1.9805
18.175 1.9805
18.175 2.2305
17.925 2.2305
17.925 1.9805
END
VIA POLYGON
1 5 -1 N 963 1 1 100 100 0 0 0 Y
TOLEVEL 6 RING NOCOVERS
TLAYNAM Via1 INH
17.925 2.5305
18.175 2.5305
18.175 2.7805
17.925 2.7805
17.925 2.5305
END
VIA POLYGON
1 5 -1 N 1007 1 1 100 100 0 0 0 Y
TOLEVEL 6 RING NOCOVERS
TLAYNAM Via1 INH
6.025 2.0805
6.275 2.0805
6.275 2.3305
6.025 2.3305
6.025 2.0805
END
VIA POLYGON
1 5 -1 N 1008 1 1 100 100 0 0 0 Y
TOLEVEL 6 RING NOCOVERS
TLAYNAM Via1 INH
6.025 2.8305
6.275 2.8305
6.275 3.0805
6.025 3.0805
6.025 2.8305
END
VIA POLYGON
1 5 -1 N 1009 1 1 100 100 0 0 0 Y
TOLEVEL 6 RING NOCOVERS
TLAYNAM Via1 INH
6.025 3.8305
6.275 3.8305
6.275 4.0805
6.025 4.0805
6.025 3.8305
END
VIA POLYGON
1 5 -1 N 1010 1 1 100 100 0 0 0 Y
TOLEVEL 6 RING NOCOVERS
TLAYNAM Via1 INH
6.025 4.5805
6.275 4.5805
6.275 4.8305
6.025 4.8305
6.025 4.5805
END
2 65 0 N 366 1 1 100 100 0 0 0 Y
TLAYNAM In1.Cu INH
5.925 2.9445
5.927 2.9225
5.932 2.9005
5.938 2.8795
5.947 2.8595
5.957 2.8395
5.969 2.8215
5.983 2.8045
5.999 2.7885
6.016 2.7745
6.034 2.7625
6.054 2.7525
6.074 2.7435
6.095 2.7375
6.117 2.7325
6.139 2.7305
6.161 2.7305
6.183 2.7325
6.205 2.7375
6.226 2.7435
6.246 2.7525
6.266 2.7625
6.284 2.7745
6.301 2.7885
6.317 2.8045
6.331 2.8215
6.343 2.8395
6.353 2.8595
6.362 2.8795
6.368 2.9005
6.373 2.9225
6.375 2.9445
6.375 2.9665
6.373 2.9885
6.368 3.0105
6.362 3.0315
6.353 3.0515
6.343 3.0715
6.331 3.0895
6.317 3.1065
6.301 3.1225
6.284 3.1365
6.266 3.1485
6.246 3.1585
6.226 3.1675
6.205 3.1735
6.183 3.1785
6.161 3.1805
6.139 3.1805
6.117 3.1785
6.095 3.1735
6.074 3.1675
6.054 3.1585
6.034 3.1485
6.016 3.1365
5.999 3.1225
5.983 3.1065
5.969 3.0895
5.957 3.0715
5.947 3.0515
5.938 3.0315
5.932 3.0105
5.927 2.9885
5.925 2.9665
5.925 2.9445
END
2 65 0 N 367 1 1 100 100 0 0 0 Y
TLAYNAM In1.Cu INH
5.925 3.9445
5.927 3.9225
5.932 3.9005
5.938 3.8795
5.947 3.8595
5.957 3.8395
5.969 3.8215
5.983 3.8045
5.999 3.7885
6.016 3.7745
6.034 3.7625
6.054 3.7525
6.074 3.7435
6.095 3.7375
6.117 3.7325
6.139 3.7305
6.161 3.7305
6.183 3.7325
6.205 3.7375
6.226 3.7435
6.246 3.7525
6.266 3.7625
6.284 3.7745
6.301 3.7885
6.317 3.8045
6.331 3.8215
6.343 3.8395
6.353 3.8595
6.362 3.8795
6.368 3.9005
6.373 3.9225
6.375 3.9445
6.375 3.9665
6.373 3.9885
6.368 4.0105
6.362 4.0315
6.353 4.0515
6.343 4.0715
6.331 4.0895
6.317 4.1065
6.301 4.1225
6.284 4.1365
6.266 4.1485
6.246 4.1585
6.226 4.1675
6.205 4.1735
6.183 4.1785
6.161 4.1805
6.139 4.1805
6.117 4.1785
6.095 4.1735
6.074 4.1675
6.054 4.1585
6.034 4.1485
6.016 4.1365
5.999 4.1225
5.983 4.1065
5.969 4.0895
5.957 4.0715
5.947 4.0515
5.938 4.0315
5.932 4.0105
5.927 3.9885
5.925 3.9665
5.925 3.9445
END
2 65 0 N 372 1 1 100 100 0 0 0 Y
TLAYNAM In1.Cu INH
17.825 2.0945
17.827 2.0725
17.832 2.0505
17.838 2.0295
17.847 2.0095
17.857 1.9895
17.869 1.9715
17.883 1.9545
17.899 1.9385
17.916 1.9245
17.934 1.9125
17.954 1.9025
17.974 1.8935
17.995 1.8875
18.017 1.8825
18.039 1.8805
18.061 1.8805
18.083 1.8825
18.105 1.8875
18.126 1.8935
18.146 1.9025
18.166 1.9125
18.184 1.9245
18.201 1.9385
18.217 1.9545
18.231 1.9715
18.243 1.9895
18.253 2.0095
18.262 2.0295
18.268 2.0505
18.273 2.0725
18.275 2.0945
18.275 2.1165
18.273 2.1385
18.268 2.1605
18.262 2.1815
18.253 2.2015
18.243 2.2215
18.231 2.2395
18.217 2.2565
18.201 2.2725
18.184 2.2865
18.166 2.2985
18.146 2.3085
18.126 2.3175
18.105 2.3235
18.083 2.3285
18.061 2.3305
18.039 2.3305
18.017 2.3285
17.995 2.3235
17.974 2.3175
17.954 2.3085
17.934 2.2985
17.916 2.2865
17.899 2.2725
17.883 2.2565
17.869 2.2395
17.857 2.2215
17.847 2.2015
17.838 2.1815
17.832 2.1605
17.827 2.1385
17.825 2.1165
17.825 2.0945
END
2 65 0 N 373 1 1 100 100 0 0 0 Y
TLAYNAM In1.Cu INH
17.825 2.6445
17.827 2.6225
17.832 2.6005
17.838 2.5795
17.847 2.5595
17.857 2.5395
17.869 2.5215
17.883 2.5045
17.899 2.4885
17.916 2.4745
17.934 2.4625
17.954 2.4525
17.974 2.4435
17.995 2.4375
18.017 2.4325
18.039 2.4305
18.061 2.4305
18.083 2.4325
18.105 2.4375
18.126 2.4435
18.146 2.4525
18.166 2.4625
18.184 2.4745
18.201 2.4885
18.217 2.5045
18.231 2.5215
18.243 2.5395
18.253 2.5595
18.262 2.5795
18.268 2.6005
18.273 2.6225
18.275 2.6445
18.275 2.6665
18.273 2.6885
18.268 2.7105
18.262 2.7315
18.253 2.7515
18.243 2.7715
18.231 2.7895
18.217 2.8065
18.201 2.8225
18.184 2.8365
18.166 2.8485
18.146 2.8585
18.126 2.8675
18.105 2.8735
18.083 2.8785
18.061 2.8805
18.039 2.8805
18.017 2.8785
17.995 2.8735
17.974 2.8675
17.954 2.8585
17.934 2.8485
17.916 2.8365
17.899 2.8225
17.883 2.8065
17.869 2.7895
17.857 2.7715
17.847 2.7515
17.838 2.7315
17.832 2.7105
17.827 2.6885
17.825 2.6665
17.825 2.6445
END
2 177 0 N 1339 1 1 100 100 0 0 0 Y
TLAYNAM In1.Cu INH
20 1.1
20 0
0 0
0 0.0605
0 0.6731470588
0 0.7372857143
0 0.8285
0 1.578863636
0 1.673714286
0 1.737285714
0 1.8285
0 2.578863636
0 2.673714286
0 2.737285714
0 2.8285
0 3.44
0 3.5
0.423 3.5
0.46 3.5
0.46 3.467015152
0.476 3.4835
0.523 3.4835
0.586 3.4575
0.625 3.4555
1.675 3.4555
1.714 3.4575
1.787 3.4875
1.843 3.5435
1.873 3.6165
1.874 3.6435
1.875 3.6555
1.875 3.7305
1.874 3.7435
1.873 3.7695
1.843 3.8425
1.787 3.8985
1.714 3.9285
1.675 3.9305
1.195 3.9305
1.195 3.93
1.105 3.93
1.105 3.9305
0.625 3.9305
0.586 3.9285
0.513 3.8985
0.457 3.8425
0.427 3.7695
0.425 3.7305
0.425 3.6555
0.427 3.6165
0.446 3.5695
0.448 3.5645
0.444 3.5175
0.423 3.5
0 3.5
0 3.5
0 3.578863636
0 3.673714286
0 3.737285714
0 3.8285
0 4.4515
0 4.578863636
0 4.673714286
0 4.735785714
0 4.9095
0 4.91
0.002 4.91
0.002 5
6.15 5
6.15 4.3105
6.04 4.2935
6.029 4.2875
6.001 4.2805
4.825 4.2805
4.825 3.6305
6.001 3.6305
6.029 3.6235
6.04 3.6175
6.15 3.6005
6.15 3.3105
6.04 3.2935
6.029 3.2875
6.001 3.2805
4.825 3.2805
4.825 2.6305
6.001 2.6305
6.029 2.6235
6.04 2.6175
6.15 2.6005
6.26 2.6175
6.271 2.6235
6.299 2.6305
6.475 2.6305
6.475 2.8065
6.482 2.8345
6.485 2.8415
6.488 2.8455
6.505 2.9555
6.488 3.0655
6.487 3.0655
6.482 3.0765
6.475 3.1045
6.475 3.2805
6.299 3.2805
6.271 3.2875
6.26 3.2935
6.15 3.3105
6.15 3.3105
6.15 3.6005
6.26 3.6175
6.271 3.6235
6.299 3.6305
6.475 3.6305
6.475 3.8065
6.482 3.8345
6.485 3.8415
6.488 3.8455
6.505 3.9555
6.488 4.0655
6.487 4.0655
6.482 4.0765
6.475 4.1045
6.475 4.2805
6.299 4.2805
6.271 4.2875
6.26 4.2935
6.15 4.3105
6.15 5
20 5
20 2.1055
18.405 2.1055
18.388 2.2155
18.337 2.3145
18.314 2.3375
18.296 2.3805
18.314 2.4235
18.337 2.4465
18.388 2.5455
18.405 2.6555
18.388 2.7655
18.337 2.8645
18.259 2.9425
18.233 2.9555
18.16 2.9935
18.05 3.0105
17.94 2.9935
17.877 2.9605
17.841 2.9425
17.772 2.8735
17.729 2.8555
16.95 2.8555
16.95 2.5055
17.695 2.5055
17.714 2.5025
17.75 2.4715
17.763 2.4465
17.786 2.4235
17.804 2.3805
17.786 2.3375
17.763 2.3145
17.725 2.2395
17.713 2.2235
17.67 2.2055
16.95 2.2055
16.95 1.8555
17.779 1.8555
17.822 1.8375
17.841 1.8185
17.94 1.7675
18.05 1.7505
18.16 1.7675
18.259 1.8185
18.337 1.8965
18.388 1.9955
18.405 2.1055
20 2.1055
20 1.1
END
3 65 3 N 393 1 1 100 100 0 0 0 Y
TLAYNAM In2.Cu_thin INH
17.825 2.0945
17.827 2.0725
17.832 2.0505
17.838 2.0295
17.847 2.0095
17.857 1.9895
17.869 1.9715
17.883 1.9545
17.899 1.9385
17.916 1.9245
17.934 1.9125
17.954 1.9025
17.974 1.8935
17.995 1.8875
18.017 1.8825
18.039 1.8805
18.061 1.8805
18.083 1.8825
18.105 1.8875
18.126 1.8935
18.146 1.9025
18.166 1.9125
18.184 1.9245
18.201 1.9385
18.217 1.9545
18.231 1.9715
18.243 1.9895
18.253 2.0095
18.262 2.0295
18.268 2.0505
18.273 2.0725
18.275 2.0945
18.275 2.1165
18.273 2.1385
18.268 2.1605
18.262 2.1815
18.253 2.2015
18.243 2.2215
18.231 2.2395
18.217 2.2565
18.201 2.2725
18.184 2.2865
18.166 2.2985
18.146 2.3085
18.126 2.3175
18.105 2.3235
18.083 2.3285
18.061 2.3305
18.039 2.3305
18.017 2.3285
17.995 2.3235
17.974 2.3175
17.954 2.3085
17.934 2.2985
17.916 2.2865
17.899 2.2725
17.883 2.2565
17.869 2.2395
17.857 2.2215
17.847 2.2015
17.838 2.1815
17.832 2.1605
17.827 2.1385
17.825 2.1165
17.825 2.0945
END
3 65 3 N 394 1 1 100 100 0 0 0 Y
TLAYNAM In2.Cu_thin INH
17.825 2.6445
17.827 2.6225
17.832 2.6005
17.838 2.5795
17.847 2.5595
17.857 2.5395
17.869 2.5215
17.883 2.5045
17.899 2.4885
17.916 2.4745
17.934 2.4625
17.954 2.4525
17.974 2.4435
17.995 2.4375
18.017 2.4325
18.039 2.4305
18.061 2.4305
18.083 2.4325
18.105 2.4375
18.126 2.4435
18.146 2.4525
18.166 2.4625
18.184 2.4745
18.201 2.4885
18.217 2.5045
18.231 2.5215
18.243 2.5395
18.253 2.5595
18.262 2.5795
18.268 2.6005
18.273 2.6225
18.275 2.6445
18.275 2.6665
18.273 2.6885
18.268 2.7105
18.262 2.7315
18.253 2.7515
18.243 2.7715
18.231 2.7895
18.217 2.8065
18.201 2.8225
18.184 2.8365
18.166 2.8485
18.146 2.8585
18.126 2.8675
18.105 2.8735
18.083 2.8785
18.061 2.8805
18.039 2.8805
18.017 2.8785
17.995 2.8735
17.974 2.8675
17.954 2.8585
17.934 2.8485
17.916 2.8365
17.899 2.8225
17.883 2.8065
17.869 2.7895
17.857 2.7715
17.847 2.7515
17.838 2.7315
17.832 2.7105
17.827 2.6885
17.825 2.6665
17.825 2.6445
END
3 65 3 N 437 1 1 100 100 0 0 0 Y
TLAYNAM In2.Cu_thin INH
5.925 2.9445
5.927 2.9225
5.932 2.9005
5.938 2.8795
5.947 2.8595
5.957 2.8395
5.969 2.8215
5.983 2.8045
5.999 2.7885
6.016 2.7745
6.034 2.7625
6.054 2.7525
6.074 2.7435
6.095 2.7375
6.117 2.7325
6.139 2.7305
6.161 2.7305
6.183 2.7325
6.205 2.7375
6.226 2.7435
6.246 2.7525
6.266 2.7625
6.284 2.7745
6.301 2.7885
6.317 2.8045
6.331 2.8215
6.343 2.8395
6.353 2.8595
6.362 2.8795
6.368 2.9005
6.373 2.9225
6.375 2.9445
6.375 2.9665
6.373 2.9885
6.368 3.0105
6.362 3.0315
6.353 3.0515
6.343 3.0715
6.331 3.0895
6.317 3.1065
6.301 3.1225
6.284 3.1365
6.266 3.1485
6.246 3.1585
6.226 3.1675
6.205 3.1735
6.183 3.1785
6.161 3.1805
6.139 3.1805
6.117 3.1785
6.095 3.1735
6.074 3.1675
6.054 3.1585
6.034 3.1485
6.016 3.1365
5.999 3.1225
5.983 3.1065
5.969 3.0895
5.957 3.0715
5.947 3.0515
5.938 3.0315
5.932 3.0105
5.927 2.9885
5.925 2.9665
5.925 2.9445
END
3 65 3 N 438 1 1 100 100 0 0 0 Y
TLAYNAM In2.Cu_thin INH
5.925 3.9445
5.927 3.9225
5.932 3.9005
5.938 3.8795
5.947 3.8595
5.957 3.8395
5.969 3.8215
5.983 3.8045
5.999 3.7885
6.016 3.7745
6.034 3.7625
6.054 3.7525
6.074 3.7435
6.095 3.7375
6.117 3.7325
6.139 3.7305
6.161 3.7305
6.183 3.7325
6.205 3.7375
6.226 3.7435
6.246 3.7525
6.266 3.7625
6.284 3.7745
6.301 3.7885
6.317 3.8045
6.331 3.8215
6.343 3.8395
6.353 3.8595
6.362 3.8795
6.368 3.9005
6.373 3.9225
6.375 3.9445
6.375 3.9665
6.373 3.9885
6.368 4.0105
6.362 4.0315
6.353 4.0515
6.343 4.0715
6.331 4.0895
6.317 4.1065
6.301 4.1225
6.284 4.1365
6.266 4.1485
6.246 4.1585
6.226 4.1675
6.205 4.1735
6.183 4.1785
6.161 4.1805
6.139 4.1805
6.117 4.1785
6.095 4.1735
6.074 4.1675
6.054 4.1585
6.034 4.1485
6.016 4.1365
5.999 4.1225
5.983 4.1065
5.969 4.0895
5.957 4.0715
5.947 4.0515
5.938 4.0315
5.932 4.0105
5.927 3.9885
5.925 3.9665
5.925 3.9445
END
3 196 3 N 1349 1 1 100 100 0 0 0 Y
TLAYNAM In2.Cu_thin INH
12.9 4.9095
12.9 4.9095
12.9 1.62
12.9 0
3.61 0
3.61 4.718447855e-16
1.110223025e-16 4.718447855e-16
1.110223025e-16 0.0605
1.110223025e-16 0.6731470588
1.110223025e-16 0.7372857143
1.110223025e-16 0.8285
1.110223025e-16 1.578863636
1.110223025e-16 1.673714286
1.110223025e-16 1.737285714
1.110223025e-16 1.8285
1.110223025e-16 2.578863636
1.110223025e-16 2.673714286
1.110223025e-16 2.737285714
1.110223025e-16 2.8285
1.110223025e-16 3.44
1.110223025e-16 3.5
0.423 3.5
0.46 3.5
0.46 3.467015152
0.4600000005 3.467015152
0.476 3.4835
0.523 3.4835
0.586 3.4575
0.625 3.4555
0.784 3.4555
0.784 3.4555
1.516 3.4555
1.516 3.4555
1.675 3.4555
1.714 3.4575
1.787 3.4875
1.787 3.4875
1.787 3.4875
1.787 3.4875
1.843 3.5435
1.843 3.5435
1.843 3.5435
1.843 3.5435
1.873 3.6165
1.873 3.6165
1.873 3.6165
1.874 3.6435
1.875 3.6555
1.875 3.6555
1.875 3.7305
1.875 3.7305
1.874 3.7435
1.874 3.7435
1.874 3.7435
1.874 3.7435
1.873 3.7695
1.873 3.7695
1.873 3.7695
1.843 3.8425
1.787 3.8985
1.787 3.8985
1.787 3.8985
1.787 3.8985
1.787 3.8985
1.787 3.8985
1.787 3.8985
1.714 3.9285
1.675 3.9305
1.195 3.9305
1.195 3.93
1.105 3.93
1.105 3.9305
0.625 3.9305
0.586 3.9285
0.513 3.8985
0.457 3.8425
0.427 3.7695
0.425 3.7305
0.425 3.6555
0.427 3.6165
0.446 3.5695
0.448 3.5645
0.444 3.5175
0.423 3.5
1.110223025e-16 3.5
1.110223025e-16 3.5
1.110223025e-16 3.578863636
1.110223025e-16 3.673714286
1.110223025e-16 3.737285714
1.110223025e-16 3.8285
1.110223025e-16 4.4515
1.110223025e-16 4.578863636
1.110223025e-16 4.673714286
1.110223025e-16 4.735785714
1.110223025e-16 4.9095
1.110223025e-16 4.91
0.002 4.91
0.002 5
6.439576 5
6.439576 4.9095
5.860424 4.9095
5.812 4.8155
5.795 4.7055
5.812 4.5955
5.863 4.4965
5.941 4.4185
5.984 4.3965
5.999 4.3855
6.017 4.3425
5.999 4.2985
5.956 4.2805
4.825 4.2805
4.825 3.6305
6.001 3.6305
6.029 3.6235
6.04 3.6175
6.15 3.6005
6.15 3.3105
6.04 3.2935
6.029 3.2875
6.001 3.2805
4.825 3.2805
4.825 2.6305
5.956 2.6305
5.975 2.6275
6.011 2.5965
6.014 2.5495
5.984 2.5145
5.941 2.4925
5.863 2.4145
5.812 2.3155
5.795 2.2055
5.812 2.0955
5.863 1.9965
5.941 1.9185
6.04 1.8675
6.15 1.8505
6.26 1.8675
6.359 1.9185
6.437 1.9965
6.475 2.070265
6.488 2.0955
6.505 2.2055
6.488 2.3155
6.437 2.4145
6.359 2.4925
6.316 2.5145
6.301 2.5255
6.283 2.5695
6.301 2.6125
6.344 2.6305
6.475 2.6305
6.475 2.8065
6.482 2.8345
6.485 2.8415
6.488 2.8455
6.505 2.9555
6.488 3.0655
6.487 3.0655
6.482 3.0765
6.475 3.1045
6.475 3.2805
6.299 3.2805
6.271 3.2875
6.26 3.2935
6.15 3.3105
6.15 3.6005
6.15 3.6005
6.26 3.6175
6.271 3.6235
6.299 3.6305
6.475 3.6305
6.475 3.8065
6.482 3.8345
6.485 3.8415
6.488 3.8455
6.505 3.9555
6.488 4.0655
6.487 4.0655
6.482 4.0765
6.475 4.1045
6.475 4.2805
6.344 4.2805
6.325 4.2835
6.289 4.3145
6.286 4.3615
6.316 4.3965
6.359 4.4185
6.437 4.4965
6.488 4.5955
6.505 4.7055
6.488 4.8155
6.439576 4.9095
6.439576 5
12.9 5
12.9 4.9095
END
3 52 3 N 1353 1 1 100 100 0 0 0 Y
TLAYNAM In2.Cu_thin INH
19.0705 3.42
19.0705 2.1055
18.405 2.1055
18.388 2.2155
18.337 2.3145
18.314 2.3375
18.296 2.3805
18.314 2.4235
18.337 2.4465
18.388 2.5455
18.405 2.6555
18.388 2.7655
18.337 2.8645
18.259 2.9425
18.233 2.9555
18.16 2.9935
18.05 3.0105
17.94 2.9935
17.877 2.9605
17.841 2.9425
17.763 2.8645
17.712 2.7655
17.695 2.6555
17.712 2.5455
17.739 2.4945
17.763 2.4465
17.786 2.4235
17.804 2.3805
17.786 2.3375
17.763 2.3145
17.712 2.2155
17.695 2.1055
17.712 1.9955
17.739 1.9445
17.763 1.8965
17.841 1.8185
17.94 1.7675
18.05 1.7505
18.16 1.7675
18.259 1.8185
18.337 1.8965
18.388 1.9955
18.405 2.1055
19.0705 2.1055
19.0705 0.0605
19.0705 0
13.15 0
13.15 0.0605
13.15 3.42
13.15 5
19.0705 5
19.0705 3.42
END
4 65 3 N 531 1 1 100 100 0 0 0 Y
TLAYNAM In3.Cu_thin INH
17.825 2.0945
17.827 2.0725
17.832 2.0505
17.838 2.0295
17.847 2.0095
17.857 1.9895
17.869 1.9715
17.883 1.9545
17.899 1.9385
17.916 1.9245
17.934 1.9125
17.954 1.9025
17.974 1.8935
17.995 1.8875
18.017 1.8825
18.039 1.8805
18.061 1.8805
18.083 1.8825
18.105 1.8875
18.126 1.8935
18.146 1.9025
18.166 1.9125
18.184 1.9245
18.201 1.9385
18.217 1.9545
18.231 1.9715
18.243 1.9895
18.253 2.0095
18.262 2.0295
18.268 2.0505
18.273 2.0725
18.275 2.0945
18.275 2.1165
18.273 2.1385
18.268 2.1605
18.262 2.1815
18.253 2.2015
18.243 2.2215
18.231 2.2395
18.217 2.2565
18.201 2.2725
18.184 2.2865
18.166 2.2985
18.146 2.3085
18.126 2.3175
18.105 2.3235
18.083 2.3285
18.061 2.3305
18.039 2.3305
18.017 2.3285
17.995 2.3235
17.974 2.3175
17.954 2.3085
17.934 2.2985
17.916 2.2865
17.899 2.2725
17.883 2.2565
17.869 2.2395
17.857 2.2215
17.847 2.2015
17.838 2.1815
17.832 2.1605
17.827 2.1385
17.825 2.1165
17.825 2.0945
END
4 65 3 N 532 1 1 100 100 0 0 0 Y
TLAYNAM In3.Cu_thin INH
17.825 2.6445
17.827 2.6225
17.832 2.6005
17.838 2.5795
17.847 2.5595
17.857 2.5395
17.869 2.5215
17.883 2.5045
17.899 2.4885
17.916 2.4745
17.934 2.4625
17.954 2.4525
17.974 2.4435
17.995 2.4375
18.017 2.4325
18.039 2.4305
18.061 2.4305
18.083 2.4325
18.105 2.4375
18.126 2.4435
18.146 2.4525
18.166 2.4625
18.184 2.4745
18.201 2.4885
18.217 2.5045
18.231 2.5215
18.243 2.5395
18.253 2.5595
18.262 2.5795
18.268 2.6005
18.273 2.6225
18.275 2.6445
18.275 2.6665
18.273 2.6885
18.268 2.7105
18.262 2.7315
18.253 2.7515
18.243 2.7715
18.231 2.7895
18.217 2.8065
18.201 2.8225
18.184 2.8365
18.166 2.8485
18.146 2.8585
18.126 2.8675
18.105 2.8735
18.083 2.8785
18.061 2.8805
18.039 2.8805
18.017 2.8785
17.995 2.8735
17.974 2.8675
17.954 2.8585
17.934 2.8485
17.916 2.8365
17.899 2.8225
17.883 2.8065
17.869 2.7895
17.857 2.7715
17.847 2.7515
17.838 2.7315
17.832 2.7105
17.827 2.6885
17.825 2.6665
17.825 2.6445
END
4 65 3 N 582 1 1 100 100 0 0 0 Y
TLAYNAM In3.Cu_thin INH
5.925 2.1945
5.927 2.1725
5.932 2.1505
5.938 2.1295
5.947 2.1095
5.957 2.0895
5.969 2.0715
5.983 2.0545
5.999 2.0385
6.016 2.0245
6.034 2.0125
6.054 2.0025
6.074 1.9935
6.095 1.9875
6.117 1.9825
6.139 1.9805
6.161 1.9805
6.183 1.9825
6.205 1.9875
6.226 1.9935
6.246 2.0025
6.266 2.0125
6.284 2.0245
6.301 2.0385
6.317 2.0545
6.331 2.0715
6.343 2.0895
6.353 2.1095
6.362 2.1295
6.368 2.1505
6.373 2.1725
6.375 2.1945
6.375 2.2165
6.373 2.2385
6.368 2.2605
6.362 2.2815
6.353 2.3015
6.343 2.3215
6.331 2.3395
6.317 2.3565
6.301 2.3725
6.284 2.3865
6.266 2.3985
6.246 2.4085
6.226 2.4175
6.205 2.4235
6.183 2.4285
6.161 2.4305
6.139 2.4305
6.117 2.4285
6.095 2.4235
6.074 2.4175
6.054 2.4085
6.034 2.3985
6.016 2.3865
5.999 2.3725
5.983 2.3565
5.969 2.3395
5.957 2.3215
5.947 2.3015
5.938 2.2815
5.932 2.2605
5.927 2.2385
5.925 2.2165
5.925 2.1945
END
4 65 3 N 583 1 1 100 100 0 0 0 Y
TLAYNAM In3.Cu_thin INH
5.925 2.9445
5.927 2.9225
5.932 2.9005
5.938 2.8795
5.947 2.8595
5.957 2.8395
5.969 2.8215
5.983 2.8045
5.999 2.7885
6.016 2.7745
6.034 2.7625
6.054 2.7525
6.074 2.7435
6.095 2.7375
6.117 2.7325
6.139 2.7305
6.161 2.7305
6.183 2.7325
6.205 2.7375
6.226 2.7435
6.246 2.7525
6.266 2.7625
6.284 2.7745
6.301 2.7885
6.317 2.8045
6.331 2.8215
6.343 2.8395
6.353 2.8595
6.362 2.8795
6.368 2.9005
6.373 2.9225
6.375 2.9445
6.375 2.9665
6.373 2.9885
6.368 3.0105
6.362 3.0315
6.353 3.0515
6.343 3.0715
6.331 3.0895
6.317 3.1065
6.301 3.1225
6.284 3.1365
6.266 3.1485
6.246 3.1585
6.226 3.1675
6.205 3.1735
6.183 3.1785
6.161 3.1805
6.139 3.1805
6.117 3.1785
6.095 3.1735
6.074 3.1675
6.054 3.1585
6.034 3.1485
6.016 3.1365
5.999 3.1225
5.983 3.1065
5.969 3.0895
5.957 3.0715
5.947 3.0515
5.938 3.0315
5.932 3.0105
5.927 2.9885
5.925 2.9665
5.925 2.9445
END
4 65 3 N 584 1 1 100 100 0 0 0 Y
TLAYNAM In3.Cu_thin INH
5.925 3.9445
5.927 3.9225
5.932 3.9005
5.938 3.8795
5.947 3.8595
5.957 3.8395
5.969 3.8215
5.983 3.8045
5.999 3.7885
6.016 3.7745
6.034 3.7625
6.054 3.7525
6.074 3.7435
6.095 3.7375
6.117 3.7325
6.139 3.7305
6.161 3.7305
6.183 3.7325
6.205 3.7375
6.226 3.7435
6.246 3.7525
6.266 3.7625
6.284 3.7745
6.301 3.7885
6.317 3.8045
6.331 3.8215
6.343 3.8395
6.353 3.8595
6.362 3.8795
6.368 3.9005
6.373 3.9225
6.375 3.9445
6.375 3.9665
6.373 3.9885
6.368 4.0105
6.362 4.0315
6.353 4.0515
6.343 4.0715
6.331 4.0895
6.317 4.1065
6.301 4.1225
6.284 4.1365
6.266 4.1485
6.246 4.1585
6.226 4.1675
6.205 4.1735
6.183 4.1785
6.161 4.1805
6.139 4.1805
6.117 4.1785
6.095 4.1735
6.074 4.1675
6.054 4.1585
6.034 4.1485
6.016 4.1365
5.999 4.1225
5.983 4.1065
5.969 4.0895
5.957 4.0715
5.947 4.0515
5.938 4.0315
5.932 4.0105
5.927 3.9885
5.925 3.9665
5.925 3.9445
END
4 59 3 N 1229 1 1 100 100 0 0 0 Y
TLAYNAM In3.Cu_thin INH
5.927 4.7385
5.932 4.7605
5.938 4.7815
5.947 4.8015
5.957 4.8215
5.969 4.8395
5.983 4.8565
5.999 4.8725
6.016 4.8865
6.034 4.8985
6.054 4.9085
6.056222 4.9095
6.243778 4.9095
6.246 4.9085
6.266 4.8985
6.284 4.8865
6.301 4.8725
6.317 4.8565
6.331 4.8395
6.343 4.8215
6.353 4.8015
6.362 4.7815
6.368 4.7605
6.373 4.7385
6.375 4.7165
6.375 4.6945
6.373 4.6725
6.368 4.6505
6.362 4.6295
6.353 4.6095
6.343 4.5895
6.331 4.5715
6.317 4.5545
6.301 4.5385
6.284 4.5245
6.266 4.5125
6.246 4.5025
6.226 4.4935
6.205 4.4875
6.183 4.4825
6.161 4.4805
6.139 4.4805
6.117 4.4825
6.095 4.4875
6.074 4.4935
6.054 4.5025
6.034 4.5125
6.016 4.5245
5.999 4.5385
5.983 4.5545
5.969 4.5715
5.957 4.5895
5.947 4.6095
5.938 4.6295
5.932 4.6505
5.927 4.6725
5.925 4.6945
5.925 4.7165
5.927 4.7385
END
4 91 3 N 1310 1 1 100 100 0 0 0 Y
TLAYNAM In3.Cu_thin INH
7.4 0.0605
3.21 0.0605
3.21 4.9095
5.860424 4.9095
5.812 4.8155
5.795 4.7055
5.812 4.5955
5.863 4.4965
5.941 4.4185
6.006 4.3855
6.033 4.3585
6.037 4.3115
6.006 4.2755
5.969 4.2565
5.941 4.2425
5.863 4.1645
5.812 4.0655
5.795 3.9555
5.812 3.8455
5.863 3.7465
5.941 3.6685
6.04 3.6175
6.15 3.6005
6.15 3.3105
6.04 3.2935
5.969 3.2565
5.941 3.2425
5.863 3.1645
5.812 3.0655
5.795 2.9555
5.812 2.8455
5.863 2.7465
5.941 2.6685
6.006 2.6355
6.033 2.6085
6.037 2.5615
6.006 2.5255
5.969 2.5065
5.941 2.4925
5.863 2.4145
5.812 2.3155
5.795 2.2055
5.812 2.0955
5.863 1.9965
5.941 1.9185
6.04 1.8675
6.15 1.8505
6.26 1.8675
6.359 1.9185
6.437 1.9965
6.488 2.0955
6.505 2.2055
6.488 2.3155
6.437 2.4145
6.359 2.4925
6.294 2.5255
6.267 2.5525
6.263 2.5995
6.294 2.6355
6.359 2.6685
6.437 2.7465
6.488 2.8455
6.505 2.9555
6.488 3.0655
6.437 3.1645
6.359 3.2425
6.29 3.2775
6.26 3.2935
6.15 3.3105
6.15 3.6005
6.15 3.6005
6.26 3.6175
6.359 3.6685
6.437 3.7465
6.488 3.8455
6.505 3.9555
6.488 4.0655
6.437 4.1645
6.359 4.2425
6.294 4.2755
6.267 4.3025
6.263 4.3495
6.294 4.3855
6.359 4.4185
6.437 4.4965
6.488 4.5955
6.505 4.7055
6.488 4.8155
6.439576 4.9095
7.4 4.9095
7.4 0.0605
END
4 50 3 N 1357 1 1 100 100 0 0 0 Y
TLAYNAM In3.Cu_thin INH
19.0705 3.4755
19.0705 2.1055
18.405 2.1055
18.388 2.2155
18.337 2.3145
18.314 2.3375
18.296 2.3805
18.314 2.4235
18.337 2.4465
18.388 2.5455
18.405 2.6555
18.388 2.7655
18.337 2.8645
18.259 2.9425
18.233 2.9555
18.16 2.9935
18.05 3.0105
17.94 2.9935
17.877 2.9605
17.841 2.9425
17.763 2.8645
17.712 2.7655
17.695 2.6555
17.712 2.5455
17.763 2.4465
17.786 2.4235
17.804 2.3805
17.786 2.3375
17.763 2.3145
17.712 2.2155
17.695 2.1055
17.712 1.9955
17.763 1.8965
17.841 1.8185
17.94 1.7675
18.05 1.7505
18.16 1.7675
18.259 1.8185
18.337 1.8965
18.388 1.9955
18.405 2.1055
19.0705 2.1055
19.0705 0.0605
18.34 0.0605
18.34 0.0605
16.4 0.0605
16.4 0.6645
16.4 4.9095
19.0705 4.9095
19.0705 3.4755
END
5 65 0 N 683 1 1 100 100 0 0 0 Y
TLAYNAM In4.Cu INH
17.825 2.0945
17.827 2.0725
17.832 2.0505
17.838 2.0295
17.847 2.0095
17.857 1.9895
17.869 1.9715
17.883 1.9545
17.899 1.9385
17.916 1.9245
17.934 1.9125
17.954 1.9025
17.974 1.8935
17.995 1.8875
18.017 1.8825
18.039 1.8805
18.061 1.8805
18.083 1.8825
18.105 1.8875
18.126 1.8935
18.146 1.9025
18.166 1.9125
18.184 1.9245
18.201 1.9385
18.217 1.9545
18.231 1.9715
18.243 1.9895
18.253 2.0095
18.262 2.0295
18.268 2.0505
18.273 2.0725
18.275 2.0945
18.275 2.1165
18.273 2.1385
18.268 2.1605
18.262 2.1815
18.253 2.2015
18.243 2.2215
18.231 2.2395
18.217 2.2565
18.201 2.2725
18.184 2.2865
18.166 2.2985
18.146 2.3085
18.126 2.3175
18.105 2.3235
18.083 2.3285
18.061 2.3305
18.039 2.3305
18.017 2.3285
17.995 2.3235
17.974 2.3175
17.954 2.3085
17.934 2.2985
17.916 2.2865
17.899 2.2725
17.883 2.2565
17.869 2.2395
17.857 2.2215
17.847 2.2015
17.838 2.1815
17.832 2.1605
17.827 2.1385
17.825 2.1165
17.825 2.0945
END
5 65 0 N 684 1 1 100 100 0 0 0 Y
TLAYNAM In4.Cu INH
17.825 2.6445
17.827 2.6225
17.832 2.6005
17.838 2.5795
17.847 2.5595
17.857 2.5395
17.869 2.5215
17.883 2.5045
17.899 2.4885
17.916 2.4745
17.934 2.4625
17.954 2.4525
17.974 2.4435
17.995 2.4375
18.017 2.4325
18.039 2.4305
18.061 2.4305
18.083 2.4325
18.105 2.4375
18.126 2.4435
18.146 2.4525
18.166 2.4625
18.184 2.4745
18.201 2.4885
18.217 2.5045
18.231 2.5215
18.243 2.5395
18.253 2.5595
18.262 2.5795
18.268 2.6005
18.273 2.6225
18.275 2.6445
18.275 2.6665
18.273 2.6885
18.268 2.7105
18.262 2.7315
18.253 2.7515
18.243 2.7715
18.231 2.7895
18.217 2.8065
18.201 2.8225
18.184 2.8365
18.166 2.8485
18.146 2.8585
18.126 2.8675
18.105 2.8735
18.083 2.8785
18.061 2.8805
18.039 2.8805
18.017 2.8785
17.995 2.8735
17.974 2.8675
17.954 2.8585
17.934 2.8485
17.916 2.8365
17.899 2.8225
17.883 2.8065
17.869 2.7895
17.857 2.7715
17.847 2.7515
17.838 2.7315
17.832 2.7105
17.827 2.6885
17.825 2.6665
17.825 2.6445
END
5 65 0 N 718 1 1 100 100 0 0 0 Y
TLAYNAM In4.Cu INH
5.925 2.9445
5.927 2.9225
5.932 2.9005
5.938 2.8795
5.947 2.8595
5.957 2.8395
5.969 2.8215
5.983 2.8045
5.999 2.7885
6.016 2.7745
6.034 2.7625
6.054 2.7525
6.074 2.7435
6.095 2.7375
6.117 2.7325
6.139 2.7305
6.161 2.7305
6.183 2.7325
6.205 2.7375
6.226 2.7435
6.246 2.7525
6.266 2.7625
6.284 2.7745
6.301 2.7885
6.317 2.8045
6.331 2.8215
6.343 2.8395
6.353 2.8595
6.362 2.8795
6.368 2.9005
6.373 2.9225
6.375 2.9445
6.375 2.9665
6.373 2.9885
6.368 3.0105
6.362 3.0315
6.353 3.0515
6.343 3.0715
6.331 3.0895
6.317 3.1065
6.301 3.1225
6.284 3.1365
6.266 3.1485
6.246 3.1585
6.226 3.1675
6.205 3.1735
6.183 3.1785
6.161 3.1805
6.139 3.1805
6.117 3.1785
6.095 3.1735
6.074 3.1675
6.054 3.1585
6.034 3.1485
6.016 3.1365
5.999 3.1225
5.983 3.1065
5.969 3.0895
5.957 3.0715
5.947 3.0515
5.938 3.0315
5.932 3.0105
5.927 2.9885
5.925 2.9665
5.925 2.9445
END
5 65 0 N 719 1 1 100 100 0 0 0 Y
TLAYNAM In4.Cu INH
5.925 3.9445
5.927 3.9225
5.932 3.9005
5.938 3.8795
5.947 3.8595
5.957 3.8395
5.969 3.8215
5.983 3.8045
5.999 3.7885
6.016 3.7745
6.034 3.7625
6.054 3.7525
6.074 3.7435
6.095 3.7375
6.117 3.7325
6.139 3.7305
6.161 3.7305
6.183 3.7325
6.205 3.7375
6.226 3.7435
6.246 3.7525
6.266 3.7625
6.284 3.7745
6.301 3.7885
6.317 3.8045
6.331 3.8215
6.343 3.8395
6.353 3.8595
6.362 3.8795
6.368 3.9005
6.373 3.9225
6.375 3.9445
6.375 3.9665
6.373 3.9885
6.368 4.0105
6.362 4.0315
6.353 4.0515
6.343 4.0715
6.331 4.0895
6.317 4.1065
6.301 4.1225
6.284 4.1365
6.266 4.1485
6.246 4.1585
6.226 4.1675
6.205 4.1735
6.183 4.1785
6.161 4.1805
6.139 4.1805
6.117 4.1785
6.095 4.1735
6.074 4.1675
6.054 4.1585
6.034 4.1485
6.016 4.1365
5.999 4.1225
5.983 4.1065
5.969 4.0895
5.957 4.0715
5.947 4.0515
5.938 4.0315
5.932 4.0105
5.927 3.9885
5.925 3.9665
5.925 3.9445
END
5 125 0 N 1367 1 1 100 100 0 0 0 Y
TLAYNAM In4.Cu INH
20 4.9095
19.0705 4.9095
19.0705 4.9095
20 4.9095
20 2.1055
18.405 2.1055
18.388 2.2155
18.337 2.3145
18.314 2.3375
18.296 2.3805
18.314 2.4235
18.337 2.4465
18.388 2.5455
18.405 2.6555
18.388 2.7655
18.337 2.8645
18.259 2.9425
18.233 2.9555
18.16 2.9935
18.05 3.0105
17.94 2.9935
17.877 2.9605
17.841 2.9425
17.763 2.8645
17.712 2.7655
17.695 2.6555
17.712 2.5455
17.763 2.4465
17.786 2.4235
17.804 2.3805
17.786 2.3375
17.763 2.3145
17.712 2.2155
17.695 2.1055
17.712 1.9955
17.763 1.8965
17.841 1.8185
17.94 1.7675
18.05 1.7505
18.16 1.7675
18.259 1.8185
18.337 1.8965
18.388 1.9955
18.405 2.1055
20 2.1055
20 1.45
20 0
4.49 0
4.49 4.440892099e-16
0 4.440892099e-16
0 0.0605
0 0.6731470588
0 0.7372857143
0 0.8285
0 1.578863636
0 1.673714286
0 1.737285714
-8.67361738e-19 1.8285
0 1.8285
0 2.578863636
0 2.673714286
0 2.737285714
0 2.8285
0 3.578863636
1.084202172e-19 3.673714286
0 3.673714286
0 3.737285714
0 3.8285
0 4.578863636
0 4.673714286
0 4.735785714
0 4.9095
0 5
6.15 5
6.15 4.3105
6.04 4.2935
6.015 4.2805
5.941 4.2425
5.863 4.1645
5.812 4.0655
5.795 3.9555
5.812 3.8455
5.863 3.7465
5.941 3.6685
6.04 3.6175
6.15 3.6005
6.15 3.3105
6.04 3.2935
6.015 3.2805
5.941 3.2425
5.863 3.1645
5.812 3.0655
5.795 2.9555
5.812 2.8455
5.863 2.7465
5.941 2.6685
6.04 2.6175
6.15 2.6005
6.26 2.6175
6.359 2.6685
6.437 2.7465
6.488 2.8455
6.505 2.9555
6.488 3.0655
6.437 3.1645
6.359 3.2425
6.29 3.2775
6.26 3.2935
6.15 3.3105
6.15 3.3105
6.15 3.6005
6.26 3.6175
6.359 3.6685
6.437 3.7465
6.488 3.8455
6.505 3.9555
6.488 4.0655
6.437 4.1645
6.359 4.2425
6.29 4.2775
6.26 4.2935
6.15 4.3105
6.15 5
20 5
20 4.9095
END
6 156 2 N 790 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu_thick INH
5.925 2.9445
5.927 2.9225
5.932 2.9005
5.938 2.8795
5.947 2.8595
5.957 2.8395
5.969 2.8215
5.983 2.8045
5.999 2.7885
6.016 2.7745
6.034 2.7625
6.054 2.7525
6.074 2.7435
6.095 2.7375
6.117 2.7325
6.139 2.7305
6.161 2.7305
6.183 2.7325
6.205 2.7375
6.226 2.7435
6.246 2.7525
6.266 2.7625
6.284 2.7745
6.301 2.7885
6.317 2.8045
6.331 2.8215
6.343 2.8395
6.353 2.8595
6.362 2.8795
6.368 2.9005
6.373 2.9225
6.375 2.9445
6.375 2.9665
6.373 2.9885
6.368 3.0105
6.362 3.0315
6.353 3.0515
6.343 3.0715
6.337 3.0795
6.568 3.3105
10.441 3.3105
11.496 2.2555
11.497 2.2535
11.503 2.2475
11.507 2.2445
11.51 2.2415
11.514 2.2395
11.518 2.2385
11.523 2.2365
11.527 2.2355
17.857 2.2355
17.863 2.2295
17.857 2.2215
17.847 2.2015
17.838 2.1815
17.832 2.1605
17.827 2.1385
17.825 2.1165
17.825 2.0945
17.827 2.0725
17.832 2.0505
17.838 2.0295
17.847 2.0095
17.857 1.9895
17.869 1.9715
17.883 1.9545
17.899 1.9385
17.916 1.9245
17.934 1.9125
17.954 1.9025
17.974 1.8935
17.995 1.8875
18.017 1.8825
18.039 1.8805
18.061 1.8805
18.083 1.8825
18.105 1.8875
18.126 1.8935
18.146 1.9025
18.166 1.9125
18.184 1.9245
18.201 1.9385
18.217 1.9545
18.231 1.9715
18.243 1.9895
18.253 2.0095
18.262 2.0295
18.268 2.0505
18.273 2.0725
18.275 2.0945
18.275 2.1165
18.273 2.1385
18.268 2.1605
18.262 2.1815
18.253 2.2015
18.243 2.2215
18.231 2.2395
18.217 2.2565
18.201 2.2725
18.184 2.2865
18.166 2.2985
18.146 2.3085
18.126 2.3175
18.105 2.3235
18.083 2.3285
18.061 2.3305
18.039 2.3305
18.017 2.3285
17.995 2.3235
17.974 2.3175
17.954 2.3085
17.934 2.2985
17.926 2.2925
17.902 2.3165
17.898 2.3195
17.894 2.3215
17.89 2.3225
17.886 2.3245
17.882 2.3255
11.552 2.3255
10.486 3.3915
10.482 3.3945
10.478 3.3965
10.474 3.3975
10.47 3.3995
10.466 3.4005
6.543 3.4005
6.539 3.3995
6.535 3.3975
6.531 3.3965
6.527 3.3945
6.523 3.3915
6.274 3.1425
6.266 3.1485
6.246 3.1585
6.226 3.1675
6.205 3.1735
6.183 3.1785
6.161 3.1805
6.139 3.1805
6.117 3.1785
6.095 3.1735
6.074 3.1675
6.054 3.1585
6.034 3.1485
6.016 3.1365
5.999 3.1225
5.983 3.1065
5.969 3.0895
5.957 3.0715
5.947 3.0515
5.938 3.0315
5.932 3.0105
5.927 2.9885
5.925 2.9665
5.925 2.9445
END
6 156 2 N 791 1 1 100 100 0 0 0 Y
TLAYNAM B.Cu_thick INH
5.925 3.9445
5.927 3.9225
5.932 3.9005
5.938 3.8795
5.947 3.8595
5.957 3.8395
5.969 3.8215
5.983 3.8045
5.999 3.7885
6.016 3.7745
6.034 3.7625
6.054 3.7525
6.074 3.7435
6.095 3.7375
6.117 3.7325
6.139 3.7305
6.161 3.7305
6.183 3.7325
6.205 3.7375
6.226 3.7435
6.246 3.7525
6.266 3.7625
6.274 3.7685
6.512 3.5305
6.513 3.5285
6.519 3.5225
6.523 3.5195
6.526 3.5165
6.53 3.5145
6.534 3.5135
6.539 3.5115
6.543 3.5105
10.523 3.5105
11.589 2.4445
11.593 2.4415
11.597 2.4395
11.601 2.4385
11.605 2.4365
11.609 2.4355
17.882 2.4355
17.886 2.4365
17.89 2.4385
17.894 2.4395
17.898 2.4415
17.902 2.4445
17.926 2.4685
17.934 2.4625
17.954 2.4525
17.974 2.4435
17.995 2.4375
18.017 2.4325
18.039 2.4305
18.061 2.4305
18.083 2.4325
18.105 2.4375
18.126 2.4435
18.146 2.4525
18.166 2.4625
18.184 2.4745
18.201 2.4885
18.217 2.5045
18.231 2.5215
18.243 2.5395
18.253 2.5595
18.262 2.5795
18.268 2.6005
18.273 2.6225
18.275 2.6445
18.275 2.6665
18.273 2.6885
18.268 2.7105
18.262 2.7315
18.253 2.7515
18.243 2.7715
18.231 2.7895
18.217 2.8065
18.201 2.8225
18.184 2.8365
18.166 2.8485
18.146 2.8585
18.126 2.8675
18.105 2.8735
18.083 2.8785
18.061 2.8805
18.039 2.8805
18.017 2.8785
17.995 2.8735
17.974 2.8675
17.954 2.8585
17.934 2.8485
17.916 2.8365
17.899 2.8225
17.883 2.8065
17.869 2.7895
17.857 2.7715
17.847 2.7515
17.838 2.7315
17.832 2.7105
17.827 2.6885
17.825 2.6665
17.825 2.6445
17.827 2.6225
17.832 2.6005
17.838 2.5795
17.847 2.5595
17.857 2.5395
17.863 2.5315
17.857 2.5255
11.634 2.5255
10.568 3.5915
10.564 3.5945
10.56 3.5965
10.556 3.5975
10.552 3.5995
10.548 3.6005
6.568 3.6005
6.337 3.8315
6.343 3.8395
6.353 3.8595
6.362 3.8795
6.368 3.9005
6.373 3.9225
6.375 3.9445
6.375 3.9665
6.373 3.9885
6.368 4.0105
6.362 4.0315
6.353 4.0515
6.343 4.0715
6.331 4.0895
6.317 4.1065
6.301 4.1225
6.284 4.1365
6.266 4.1485
6.246 4.1585
6.226 4.1675
6.205 4.1735
6.183 4.1785
6.161 4.1805
6.139 4.1805
6.117 4.1785
6.095 4.1735
6.074 4.1675
6.054 4.1585
6.034 4.1485
6.016 4.1365
5.999 4.1225
5.983 4.1065
5.969 4.0895
5.957 4.0715
5.947 4.0515
5.938 4.0315
5.932 4.0105
5.927 3.9885
5.925 3.9665
5.925 3.9445
END
END GEO
OPT
MAX 100
END OPT
VARSWP
ENABLED Y
FREQ Y AY ABS_ENTRY 0.01 20.0 -1 300 
END
END VARSWP
```
